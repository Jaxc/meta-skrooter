# IAR project stmp157-olinuxino-lime2.ewp, settings and files
configuration stmp157-olinuxino-lime2 (ARM, debug)
  General.OGChipSelectEditMenu: STM32MP157D_M4 ST STM32MP157D_M4
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 59
  General.FPU2: 6
  ICCARM.CCDefines: CORE_CM4; USE_HAL_DRIVER; STM32MP157Dxx
  ICCARM.CCIncludePath2: ../CM4/Core/Inc; ../Drivers/STM32MP1xx_HAL_Driver/Inc; ../Drivers/STM32MP1xx_HAL_Driver/Inc/Legacy; ../Drivers/CMSIS/Device/ST/STM32MP1xx/Include; ../Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: stmp157-olinuxino-lime2.hex
  ILINK.IlinkOutputFile: stmp157-olinuxino-lime2.out
  ILINK.IlinkIcfFile: stm32mp15xx_sram.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Application/EWARM
    ./: startup_stm32mp15xx.s
  group Application/User/CM4/Core
    ../CM4/Core/Src/: main.c stm32mp1xx_it.c stm32mp1xx_hal_msp.c
  group Drivers/STM32MP1xx_HAL_Driver
    ../Drivers/STM32MP1xx_HAL_Driver/Src/: stm32mp1xx_hal_rcc.c stm32mp1xx_hal_rcc_ex.c stm32mp1xx_hal_gpio.c stm32mp1xx_hal_hsem.c stm32mp1xx_hal_dma.c stm32mp1xx_hal_dma_ex.c stm32mp1xx_hal_mdma.c stm32mp1xx_hal_pwr.c stm32mp1xx_hal_pwr_ex.c stm32mp1xx_hal_cortex.c stm32mp1xx_hal.c stm32mp1xx_hal_exti.c stm32mp1xx_hal_ipcc.c stm32mp1xx_hal_tim.c stm32mp1xx_hal_tim_ex.c
  group Drivers/CMSIS
    ../Common/System/: system_stm32mp1xx.c
